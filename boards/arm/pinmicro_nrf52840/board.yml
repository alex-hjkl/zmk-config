## boards/arm/pinmicro_nrf52840/board.yml
```yaml
board:
  name: pinmicro_nrf52840
  vendor: pinmicro
  socs:
    - name: nrf52840
```
